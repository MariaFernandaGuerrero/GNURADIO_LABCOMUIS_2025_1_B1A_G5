options:
  parameters:
    generate_options: qt_gui
    id: pruebaPAM
    output_language: python
    title: pruebaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitudmpulsos
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: ancho impulsos
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: freqmensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: frecuencia impulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: moduladorPAMV2_0
  id: moduladorPAMV2
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', moduladorPAMV2_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [moduladorPAMV2_0, '0', qtgui_freq_sink_x_0, '0']
- [moduladorPAMV2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
