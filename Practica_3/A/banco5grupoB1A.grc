options:
  parameters:
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '1'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de la portadora
    start: 50e5
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente Ka
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125e5/8
  states: {}
- name: Modulador_AM_0
  id: Modulador_AM
  parameters:
    Ac: Ac
    ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: y
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_AM_0, '0', qtgui_freq_sink_x_0, '0']
- [Modulador_AM_0, '0', qtgui_time_sink_x_0, '0']
- [Modulador_AM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Modulador_AM_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
