options:
  parameters:
    generate_options: qt_gui
    id: practica_1b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia tx
    start: '0'
    step: '0.5'
    stop: '30'
    value: '10'
  states: {}
- name: a
  id: variable_qtgui_range
  parameters:
    label: amplitud señal tx
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '500e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/128
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: a
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
