options:
  parameters:
    generate_options: qt_gui
    id: pruebaPAM
    output_language: python
    title: pruebaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitudmpulsos
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: ancho impulsos
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D_1
  id: variable_qtgui_range
  parameters:
    label: retardo1
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D_2
  id: variable_qtgui_range
  parameters:
    label: retardo2
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D_3
  id: variable_qtgui_range
  parameters:
    label: retardo3
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fc_LPF
  id: variable_qtgui_range
  parameters:
    label: freqmensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: freqmensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: frecuencia impulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D_1
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D_2
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: D_3
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fc_LPF
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: moduladorPAMV2_0
  id: moduladorPAMV2
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: moduladorPAMV2_0_0
  id: moduladorPAMV2
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: moduladorPAMV2_0_1
  id: moduladorPAMV2
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: moduladorPAMV2_0_2
  id: moduladorPAMV2
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: moduladorPAMV2_1
  id: moduladorPAMV2
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', moduladorPAMV2_0, '0']
- [analog_sig_source_x_0_0, '0', moduladorPAMV2_0_0, '0']
- [analog_sig_source_x_0_1, '0', moduladorPAMV2_0_1, '0']
- [analog_sig_source_x_0_2, '0', moduladorPAMV2_0_2, '0']
- [blocks_add_xx_0, '0', blocks_delay_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_1, '0', moduladorPAMV2_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [moduladorPAMV2_0, '0', blocks_add_xx_0, '0']
- [moduladorPAMV2_0, '0', qtgui_time_sink_x_0, '0']
- [moduladorPAMV2_0_0, '0', blocks_delay_0_0, '0']
- [moduladorPAMV2_0_1, '0', blocks_delay_0_1, '0']
- [moduladorPAMV2_0_2, '0', blocks_delay_0_2, '0']
- [moduladorPAMV2_1, '0', low_pass_filter_0, '0']
- [moduladorPAMV2_1, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
